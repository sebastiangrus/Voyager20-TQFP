# Repository sebastiangrus/Voyager20-TQFP

## KiCad design Voyager20-TQFP.kicad_pcb

Board: 2 copper layers, 73.0 x 95.2 mm, 91 parts (68 on the bottom side), 70 nets.

Parts:
C1, C2: 22p; C_0603
C3: 1uF; C_0603
C4, C5: 0.1u; C_0603
C6: 4.7u; C_0603
CR1, CR2, CR3, CR4: 0.1u; C_0603
D1, D2, D3, D4, D5, D6, D7, D8, D10, D11, D12, D13, D14, D15, D16, D17, D19, D20, D21, D22: SOD-123; D_SOD-123
D9, D18, D23, D24: WS2812B; LED_WS2812B-PLCC4
F1: 500mA; Fuse_SMD1206_Reflow
MX1, MX2, MX3, MX4, MX5, MX6, MX7, MX8, MX9, MX10, MX11, MX12, MX13, MX14, MX15, MX16, MX17, MX18, MX19, MX20: MX-1U
MX-E-1, MX-E-2, MX-E-3: MX-2U; MX-2U-ReversedStabilizers
Q1: Q_NPN_BEC; SOT-23
R1, R5: 10k; R_0805
R2, R3: 22; R_0805
R4, R6: 5.1k; R_0805
R7, R8, R9, R10, R11, R12, R13, R14, R15, R16, R17, R18, R19, R20, R21, R22, R23, R24, R25, R26, R27: 1k; R_0805
SW1: SW_Push; SKQG-1155865
U1: ATmega32U2-AU; TQFP-32_7x7mm_P0.8mm
U2: PRTR5V0U2X; SOT143B
USB1: HRO-TYPE-C-31-M-12; HRO-TYPE-C-31-M-12-Assembly
Y1: 16MHz; Crystal_SMD_3225-4pin_3.2x2.5mm

Connections:
+5V: C4.1, C5.1, C6.1, CR1.1, CR2.1, CR3.1, CR4.1, D9.1, D18.1, D23.1, D24.1, F1.1, MX1.3, MX2.3, MX3.3, MX4.3, MX5.3, MX6.3, MX7.3, MX8.3, MX9.3, MX10.3, MX11.3, MX12.3, MX13.3, MX14.3, MX15.3, MX16.3, MX17.3, MX18.3, MX19.3, MX20.3, MX-E-1.3, MX-E-2.3, MX-E-3.3, R1.1, U1.4, U1.31, U1.32
COL0: MX1.1, MX5.1, MX9.1, MX13.1, MX17.1, MX-E-3.1, U1.26
COL1: MX2.1, MX6.1, MX10.1, MX14.1, MX18.1, U1.25
COL2: MX3.1, MX7.1, MX11.1, MX15.1, MX19.1, U1.17
COL3: MX4.1, MX8.1, MX12.1, MX16.1, MX20.1, MX-E-1.1, MX-E-2.1, U1.16
D+: R3.2, U1.29
D-: R2.1, U1.30
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, CR1.2, CR2.2, CR3.2, CR4.2, D9.3, D18.3, D23.3, D24.3, Q1.2, R4.2, R5.1, R6.2, SW1.1, U1.3, U1.28, U2.1, USB1.1, USB1.12, USB1.13, Y1.2, Y1.4
LEDGND: Q1.3, R7.2, R8.2, R9.2, R10.2, R11.2, R12.2, R13.2, R14.2, R15.2, R16.2, R17.2, R18.2, R19.2, R20.2, R21.2, R22.2, R23.2, R24.2, R25.2, R26.2
unnamed: C1.1, U1.1, Y1.1
unnamed: C2.1, U1.2, Y1.3
unnamed: C3.1, U1.27
unnamed: D1.2, MX1.2
unnamed: D2.2, MX2.2
unnamed: D3.2, MX3.2
unnamed: D4.2, MX4.2
unnamed: D5.2, MX5.2
unnamed: D6.2, MX6.2
unnamed: D7.2, MX7.2
unnamed: D8.2, MX8.2
unnamed: D10.2, MX9.2
unnamed: D11.2, MX10.2
unnamed: D12.2, MX11.2
unnamed: D13.2, MX12.2, MX-E-1.2
unnamed: D14.2, MX13.2
unnamed: D15.2, MX14.2
unnamed: D16.2, MX15.2
unnamed: D17.2, MX16.2
unnamed: D18.2, D23.4
unnamed: D9.2, D18.4
unnamed: D19.2, MX17.2, MX-E-3.2
unnamed: D20.2, MX18.2
unnamed: D21.2, MX19.2
unnamed: D22.2, MX20.2, MX-E-2.2
unnamed: D23.2, D24.4
unnamed: MX1.4, R7.1
unnamed: MX2.4, R8.1
unnamed: MX3.4, R9.1
unnamed: MX4.4, R10.1
unnamed: MX5.4, R11.1
unnamed: MX6.4, R12.1
unnamed: MX7.4, R13.1
unnamed: MX8.4, R14.1
unnamed: MX9.4, R15.1
unnamed: MX10.4, R16.1
unnamed: MX11.4, R17.1
unnamed: MX13.4, R19.1
unnamed: MX14.4, R20.1
unnamed: MX15.4, R21.1
unnamed: MX16.4, R22.1
unnamed: MX18.4, R24.1
unnamed: MX19.4, R25.1
unnamed: MX12.4, MX-E-1.4, R18.1
unnamed: MX20.4, MX-E-2.4, R26.1
unnamed: MX17.4, MX-E-3.4, R23.1
unnamed: Q1.1, R27.1
unnamed: R1.2, SW1.2, U1.24
unnamed: R2.2, U2.3, USB1.5, USB1.7
unnamed: R3.1, U2.2, USB1.6, USB1.8
unnamed: R4.1, USB1.10
unnamed: R5.2, U1.13
unnamed: R6.1, USB1.4
unnamed: R27.2, U1.21
RGBLED: D9.4, U1.19
ROW0: D1.1, D2.1, D3.1, D4.1, U1.7
ROW1: D5.1, D6.1, D7.1, D8.1, U1.8
ROW2: D10.1, D11.1, D12.1, D13.1, U1.23
ROW3: D14.1, D15.1, D16.1, D17.1, U1.22
ROW4: D19.1, D20.1, D21.1, D22.1, U1.20
VCC: F1.2, U2.4, USB1.2, USB1.11

## Commit log

2023-03-22 zamowione 2023-03-12
2023-03-25 fixed +5v and GND lol
